PACKAGECONFIG_append = " pcre ssl ssh2 libz"
